# IAR project gainspan_rl78_cloud.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F101LE RL78 - R5F101LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 600
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: .; applilet3_src\
  ARL78.AsmIncludePath: .
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f101le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core 2 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: HostApp.h main.c
  group Apps
    Apps/: App_Common.c App_Exosite.c Apps.h
  group CmdLib
    CmdLib/: AtCmdLib.c AtCmdLib.h
  group drv
    drv/: ADC.c ADC.h GainSpan_SPI.c GainSpan_SPI.h I2C.c I2C.h IntervalTimer.c IntervalTimer.h SAU.h SPI_CSI10.c SPI_CSI10.h UART0.c UART0.h
  group drv/Glyph
    drv/Glyph/: Glyph_API.h Glyph_cfg.h glyph_register.c glyph_types.h lcd.c lcd.h RL78GlyphLib_Debug.r87 RL78GlyphLib_Release.r87
  group init
    init/: hwsetup.c hwsetup.h
  group sensors
    sensors/: eeprom.c eeprom.h Potentiometer.c Potentiometer.h Temperature_ADT7420.c Temperature_ADT7420.h
  group system
    system/: console.c console.h mstimer.c mstimer.h platform.h YRDKRL78G13.h
