<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gainspan_rl78_cloud.ewp</path>
  </project>
  <batchBuild/>
</workspace>


